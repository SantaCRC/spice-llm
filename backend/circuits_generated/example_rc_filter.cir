* RC Low-Pass Filter Example
* Cutoff frequency: ~159 Hz (R=1k, C=1uF)

V1 in 0 DC 0 AC 1 0    ; AC source (1V amplitude, 0 phase)
R1 in out 1k           ; 1kΩ resistor
C1 out 0 1u            ; 1μF capacitor

* Analysis commands
.control
ac dec 10 1 100k       ; AC analysis: 10 points per decade from 1Hz to 100kHz
plot vdb(out)          ; Plot output voltage in dB
.endc

* End of netlist
.end
