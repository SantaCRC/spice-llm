Ejemplo de netlist RC
V1 1 0 DC 5
R1 1 2 1k
C1 2 0 10u
.tran 1m 10m
.end
